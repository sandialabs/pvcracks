* Import the diode model
.include SolarCell.cp

* Define the DC sweep
V1 1 0 DC 0V

X1 1 2 3    Cell Rs=0.008979231433363738 Rp=0.8351784411578747 I=7.588187939162058 BV=30 N=1.9970488379717133 Is=3.762260002139528e-05
X3 3 4 5    Cell Rs=0.005858519335145538 Rp=626.3520512442827 I=8.221783870645835 BV=30 N=1.3389733896769969 Is=1.19572361089268e-07
X5 5 6 7    Cell Rs=0.005046405978292938 Rp=8.986410884420332 I=8.23384930775584 BV=30 N=1.730266008500821 Is=6.987569886149879e-06
X7 7 8 9    Cell Rs=0.005918338451507538 Rp=1095.1491246324647 I=8.268208346813537 BV=30 N=1.2468476334415306 Is=3.0252537409791404e-08
X9 9 10 11    Cell Rs=0.005868702480494438 Rp=529.9591857660071 I=8.231207445187515 BV=30 N=1.644546784343845 Is=3.558480874747065e-06
X11 11 12 13    Cell Rs=0.0064439007022137375 Rp=97.04720431199866 I=8.309195258836255 BV=30 N=1.5678352402276472 Is=1.6107646002124132e-06
X13 13 14 15    Cell Rs=0.006370439209987238 Rp=1247.6765749052051 I=8.24369138472723 BV=30 N=1.267887290212162 Is=3.5194564645417174e-08
X15 15 16 17    Cell Rs=0.006169598141722438 Rp=1239.1590775239831 I=8.173282406392486 BV=30 N=1.2382581449179293 Is=2.7166225850548166e-08
X17 17 18 0    Cell Rs=0.0095950447475012 Rp=88.78696501004563 I=8.160221150318453 BV=30 N=1.5730299192822572 Is=1.7951591225859276e-06

.control
* set the sweep for the apropriate voltage range in steps of V_Step
dc V1 2.9971455493242216e-05 5.6895217036856325 0.001
set filetype=ascii
write /ceph-home/nrjost/githome/pvcracks_dev2/pvcracks/pvspice_lite/solar_circuit.out
write /ceph-home/nrjost/githome/pvcracks_dev2/pvcracks/pvspice_lite/solar_circuit.txt

quit
.endc
