* Import the diode model
.include SolarCell.cp

* Define the DC sweep
V1 1 0 DC 0V

X1 1 2 3    Cell Rs=0.008979231433363738 Rp=0.8351784411578747 I=7.588187939162058 BV=30 N=1.9970488379717133 Is=3.762260002139528e-05
X3 3 4 5    Cell Rs=0.008979231433363738 Rp=0.8351784411578747 I=7.588187939162058 BV=30 N=1.9970488379717133 Is=3.762260002139528e-05
X5 5 6 7    Cell Rs=0.008979231433363738 Rp=0.8351784411578747 I=7.588187939162058 BV=30 N=1.9970488379717133 Is=3.762260002139528e-05
X7 7 8 0    Cell Rs=0.0125665495348044 Rp=0.8351784411578747 I=7.588187939162058 BV=30 N=1.9970488379717133 Is=3.762260002139528e-05

.control
* set the sweep for the apropriate voltage range in steps of V_Step
dc V1 0.0 2.66 0.001
set filetype=ascii
write /home/bkbyfor/pvcracks_stuff/pvcracks/pvcracks/pvspice_lite/solar_circuit.out
write /home/bkbyfor/pvcracks_stuff/pvcracks/pvcracks/pvspice_lite/solar_circuit.txt

quit
.endc
